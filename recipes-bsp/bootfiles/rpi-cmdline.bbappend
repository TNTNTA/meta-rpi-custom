FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

ENABLE_UART="1"