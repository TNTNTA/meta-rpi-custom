PACKAGECONFIG:append = " examples"